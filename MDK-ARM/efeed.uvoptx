<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_optx.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj; *.o</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
    <nMigrate>0</nMigrate>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>efeed</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>72000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>0</RunSim>
        <RunTarget>1</RunTarget>
        <RunAbUc>0</RunAbUc>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath></ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>18</CpuCode>
      <DebugOpt>
        <uSim>1</uSim>
        <uTrg>0</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>1</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>1</tRfunc>
        <tRbox>1</tRbox>
        <tRtrace>1</tRtrace>
        <sRSysVw>1</sRSysVw>
        <tRSysVw>1</tRSysVw>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <bEvRecOn>1</bEvRecOn>
        <nTsel>5</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile>.\Gpio2.ini</sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>STLink\ST-LINKIII-KEIL_SWO.dll</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGDARM</Key>
          <Name>(1010=-1,-1,-1,-1,0)(1007=-1,-1,-1,-1,0)(1008=-1,-1,-1,-1,0)(1009=-1,-1,-1,-1,0)(100=-1,-1,-1,-1,0)(110=-1,-1,-1,-1,0)(111=-1,-1,-1,-1,0)(1011=-1,-1,-1,-1,0)(180=-1,-1,-1,-1,0)(120=1091,190,1721,844,0)(121=1137,308,1767,962,1)(122=-1,-1,-1,-1,0)(123=-1,-1,-1,-1,0)(140=-1,-1,-1,-1,0)(240=158,209,754,735,0)(190=-1,-1,-1,-1,0)(200=-1,-1,-1,-1,0)(170=-1,-1,-1,-1,0)(130=-1,-1,-1,-1,0)(131=-1,-1,-1,-1,0)(132=-1,-1,-1,-1,0)(133=819,0,1707,1151,0)(160=-1,-1,-1,-1,0)(161=-1,-1,-1,-1,0)(162=-1,-1,-1,-1,0)(210=-1,-1,-1,-1,0)(211=-1,-1,-1,-1,0)(220=-1,-1,-1,-1,0)(221=-1,-1,-1,-1,0)(230=-1,-1,-1,-1,0)(234=-1,-1,-1,-1,0)(231=-1,-1,-1,-1,0)(232=-1,-1,-1,-1,0)(233=-1,-1,-1,-1,0)(150=-1,-1,-1,-1,0)(151=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMRTXEVENTFLAGS</Key>
          <Name>-L70 -Z18 -C0 -M0 -T1</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGTARM</Key>
          <Name>(1010=-1,-1,-1,-1,0)(1007=-1,-1,-1,-1,0)(1008=-1,-1,-1,-1,0)(1009=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name>-T0</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGUARM</Key>
          <Name>(105=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>UL2CM3(-S0 -C0 -P0 -FD20000000 -FC1000 -FN1 -FF0STM32F10x_128 -FS08000000 -FL020000 -FP0($$Device:STM32F103C8$Flash\STM32F10x_128.FLM))</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ST-LINKIII-KEIL_SWO</Key>
          <Name>-U-O142 -O2254 -S0 -C0 -A0 -N00("ARM CoreSight SW-DP") -D00(1BA01477) -L00(0) -TO18 -TC10000000 -TP21 -TDS8007 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -FO7 -FD20000000 -FC800 -FN1 -FF0STM32F10x_128.FLM -FS08000000 -FL010000 -FP0($$Device:STM32F103C8$Flash\STM32F10x_128.FLM)</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <Breakpoint>
        <Bp>
          <Number>0</Number>
          <Type>0</Type>
          <LineNumber>261</LineNumber>
          <EnabledFlag>1</EnabledFlag>
          <Address>134227704</Address>
          <ByteObject>0</ByteObject>
          <HtxType>0</HtxType>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>1</BreakIfRCount>
          <Filename>../Src/stm32f1xx_it.c</Filename>
          <ExecCommand></ExecCommand>
          <Expression>\\efeed\../Src/stm32f1xx_it.c\261</Expression>
        </Bp>
      </Breakpoint>
      <WatchWindow1>
        <Ww>
          <count>0</count>
          <WinNumber>1</WinNumber>
          <ItemText>buttons_flag_set,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>1</count>
          <WinNumber>1</WinNumber>
          <ItemText>buttons</ItemText>
        </Ww>
        <Ww>
          <count>2</count>
          <WinNumber>1</WinNumber>
          <ItemText>bt[0]</ItemText>
        </Ww>
        <Ww>
          <count>3</count>
          <WinNumber>1</WinNumber>
          <ItemText>bt[0].GPIOx-&gt;IDR</ItemText>
        </Ww>
        <Ww>
          <count>4</count>
          <WinNumber>1</WinNumber>
          <ItemText>state</ItemText>
        </Ww>
        <Ww>
          <count>5</count>
          <WinNumber>1</WinNumber>
          <ItemText>t4dier[TIM_DIER_UIE_Pos]</ItemText>
        </Ww>
      </WatchWindow1>
      <ToolboxButtons>
        <Wi>
          <IntNumber>0</IntNumber>
          <FirstString>Button tacho2</FirstString>
          <SecondString>tacho2 ()</SecondString>
        </Wi>
        <Wi>
          <IntNumber>1</IntNumber>
          <FirstString>Button longpress</FirstString>
          <SecondString>button_lpstart ()</SecondString>
        </Wi>
        <Wi>
          <IntNumber>2</IntNumber>
          <FirstString>Button pulse2</FirstString>
          <SecondString>pulse2 ()</SecondString>
        </Wi>
      </ToolboxButtons>
      <Tracepoint>
        <THDelay>0</THDelay>
      </Tracepoint>
      <DebugFlag>
        <trace>0</trace>
        <periodic>1</periodic>
        <aLwin>0</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
      <bLintAuto>0</bLintAuto>
      <bAutoGenD>0</bAutoGenD>
      <LntExFlags>0</LntExFlags>
      <pMisraName></pMisraName>
      <pszMrule></pszMrule>
      <pSingCmds></pSingCmds>
      <pMultCmds></pMultCmds>
      <LogicAnalyzers>
        <Wi>
          <IntNumber>0</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000006000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>1</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000004000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>2</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000008000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>3</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000001000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>4</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000007000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>5</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000002000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>6</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000005000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>7</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000003000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>8</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000006000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>9</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000004000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>10</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000008000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>11</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000001000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>12</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000007000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>13</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000002000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>14</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000005000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>15</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000003000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>16</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000006000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>17</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000004000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>18</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000008000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>19</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000001000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>20</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000007000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>21</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000002000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>22</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000005000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>23</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000003000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>24</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000006000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>25</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000004000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>26</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000008000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>27</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000001000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>28</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000007000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>29</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000002000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>30</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000005000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>31</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000003000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>32</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000006000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>33</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000004000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>34</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000008000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>35</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000001000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>36</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000007000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>37</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000002000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>38</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000005000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>39</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000003000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>40</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000006000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>41</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000004000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>42</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000008000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>43</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000001000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>44</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000007000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>45</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000002000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>46</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000005000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>47</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000003000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>48</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000006000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>49</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000004000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>50</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000008000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>51</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000001000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>52</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000007000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>53</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000002000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>54</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000005000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>55</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000003000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>56</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000006000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>57</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000004000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>58</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000008000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>59</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000001000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>60</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000007000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>61</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000002000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>62</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000005000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>63</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000003000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>64</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000006000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>65</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000004000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>66</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000008000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>67</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000001000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>68</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000007000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>69</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000002000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>70</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000005000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>71</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000003000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>72</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000006000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>73</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000004000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>74</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000008000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>75</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000001000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>76</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000007000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>77</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000002000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>78</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000005000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>79</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000003000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>80</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000006000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>81</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000004000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>82</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000008000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>83</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000001000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>84</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000007000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>85</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000002000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>86</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000005000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>87</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000003000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>88</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000006000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>89</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000004000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>90</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000008000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>91</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000001000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>92</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000007000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>93</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000002000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>94</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000005000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>95</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000003000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>96</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000006000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>97</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000004000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>98</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000008000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>99</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000001000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>100</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000007000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>101</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000002000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>102</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000005000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>103</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000003000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>104</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000006000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>105</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000004000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>106</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000008000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>107</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000001000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>108</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000007000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>109</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000002000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>110</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000005000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>111</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000003000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>112</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000006000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>113</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000004000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>114</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000008000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>115</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000001000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>116</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000007000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>117</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000002000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>118</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000005000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>119</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000003000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>120</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000006000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>121</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000004000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>122</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000008000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>123</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000001000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>124</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000007000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>125</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000002000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>126</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000005000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
        <Wi>
          <IntNumber>127</IntNumber>
          <FirstString>`PORTB</FirstString>
          <SecondString>FF000000000000000000000000000000E0FFEF4001000000000000000000000000000000504F5254420000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000100000003000000000000000000C03F11000000000000000000000000000000000000007A2B0008</SecondString>
        </Wi>
      </LogicAnalyzers>
      <DebugDescription>
        <Enable>1</Enable>
        <EnableLog>0</EnableLog>
        <Protocol>2</Protocol>
        <DbgClock>10000000</DbgClock>
      </DebugDescription>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>Drivers/STM32F1xx_HAL_Driver</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_gpio_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_gpio_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_i2c.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_i2c.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>3</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_tim.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_tim.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>4</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_tim_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_tim_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>5</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>6</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_rcc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_rcc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>7</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_rcc_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_rcc_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>8</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_gpio.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_gpio.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>9</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_dma.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_dma.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>10</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_cortex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_cortex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>11</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_pwr.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_pwr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>12</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_flash.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_flash.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>13</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Drivers/STM32F1xx_HAL_Driver/Src/stm32f1xx_hal_flash_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_flash_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Drivers/CMSIS</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>14</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..//Src/system_stm32f1xx.c</PathWithFileName>
      <FilenameWithoutPath>system_stm32f1xx.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Application/User</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>15</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Src\fonts2.c</PathWithFileName>
      <FilenameWithoutPath>fonts2.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>16</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Src\ssd1306.c</PathWithFileName>
      <FilenameWithoutPath>ssd1306.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>17</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Src\i2c_interface.c</PathWithFileName>
      <FilenameWithoutPath>i2c_interface.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>18</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Src\buttons.c</PathWithFileName>
      <FilenameWithoutPath>buttons.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>19</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Src\screen.c</PathWithFileName>
      <FilenameWithoutPath>screen.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>20</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Src/main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>21</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Src/stm32f1xx_it.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_it.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>22</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>../Src/stm32f1xx_hal_msp.c</PathWithFileName>
      <FilenameWithoutPath>stm32f1xx_hal_msp.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>23</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\Src\fsm.c</PathWithFileName>
      <FilenameWithoutPath>fsm.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Application/MDK-ARM</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>24</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>startup_stm32f103xb.s</PathWithFileName>
      <FilenameWithoutPath>startup_stm32f103xb.s</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>::CMSIS</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>1</RteFlg>
  </Group>

</ProjectOpt>
